options:
  parameters:
    author: K.Chow
    category: '[gr-gen-tools]/Communications'
    description: Scan and record signals with the RTL
    generate_options: hb_qt_gui
    id: rtl_scan_and_record
    output_language: python
  states: {}

blocks:
- name: carrier_frequency
  id: variable_qtgui_range
  parameters:
    start: 80e6
    step: 1e6
    stop: 1800e6
    value: 93.1e6
  states: {}
- name: enable
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Enable Recorder
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: gr_gen_tools_recorder_0
  id: gr_gen_tools_recorder
  parameters:
    dur: '60.0'
    enable: enable
    fs: samp_rate
    out_dir: /tmp
    rf: carrier_frequency
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    optional: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: carrier_frequency
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 2e6
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: carrier_frequency
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_rtlsdr_source_0, '0', gr_gen_tools_recorder_0, '0']
- [soapy_rtlsdr_source_0, '0', pad_sink_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
