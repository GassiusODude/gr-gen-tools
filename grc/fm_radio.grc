options:
  parameters:
    author: Keith Chow
    category: '[gr-gen-tools]/Communications'
    description: FM demodulator
    generate_options: hb
    id: fm_radio
    output_language: python
    title: FM Demodulator
  states: {}

blocks:
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: fm_deviation
  id: parameter
  parameters:
    label: FM Frequency Deviation
    type: eng_float
    value: 75e3
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: fm_deviation
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: fm_deviation/10.0
    win: window.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    optional: 'True'
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate_out / samp_rate
    type: fff
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sampling Rate (input)
    type: eng_float
    value: 2e6
  states: {}
- name: samp_rate_out
  id: parameter
  parameters:
    label: Sampling Rate (output)
    type: eng_float
    value: 8e3
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', pfb_arb_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [pad_source_0, '0', low_pass_filter_0, '0']
- [pfb_arb_resampler_xxx_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
